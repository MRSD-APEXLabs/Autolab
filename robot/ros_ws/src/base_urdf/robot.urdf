Commit message: Basic planning checkpoint

File: robot/ros_ws/src/base_urdf/robot.urdf (robot description, URDF)
Before this commit: robot demo_bot, 19 links, 18 joints
Joints:
- joint world_to_robot: origin xyz=0 0 0 rpy=0 3.14159261 0 -> xyz=0 0 0.893 rpy=0 3.14159261 0
